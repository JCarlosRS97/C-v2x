<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>comment</key><value>N_RB_sc*N_UL_RB</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3000000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>cv2x_slss_generator</key>
<param><key>id</key><value>cv2x_slss_generator_0</value></param>
<param><key>slssId</key><value>301</value></param>
<param><key>syncPeriod</key><value>1</value></param>
<param><key>syncOffsetIndicator1</key><value>1</value></param>
<param><key>syncOffsetIndicator2</key><value>0</value></param>
</block>
<block>
<key>cv2x_subframe_to_symbol_vector</key>
<param><key>id</key><value>cv2x_subframe_to_symbol_vector_0</value></param>
<param><key>NSLRB</key><value>6</value></param>
<param><key>NFFT</key><value>fft_len</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fft_len</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>fft_size</key><value>fft_len</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>howto_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>howto_ofdm_cyclic_prefixer_0</value></param>
<param><key>cp_lengths</key><value>(int(160.0/2048*fft_len), int(144.0/2048*fft_len), int(144.0/2048*fft_len), int(144.0/2048*fft_len), int(144.0/2048*fft_len), int(144.0/2048*fft_len),int(144.0/2048*fft_len))</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>len_tag_key</key><value></value></param>
<param><key>rolloff</key><value>0</value></param>
</block>
<block>
<key>lte_extract_subcarriers_vcvc</key>
<param><key>id</key><value>lte_extract_subcarriers_vcvc_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
<param><key>N_rb_dl</key><value>6</value></param>
</block>
<block>
<key>lte_pss_calculator_vcm</key>
<param><key>id</key><value>lte_pss_calculator_vcm_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
</block>
<block>
<key>lte_pss_symbol_selector_cvc</key>
<param><key>id</key><value>lte_pss_symbol_selector_cvc_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
</block>
<block>
<key>lte_rough_symbol_sync_cc</key>
<param><key>id</key><value>lte_rough_symbol_sync_cc_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>cv2x_slss_generator_0</source_block_id><sink_block_id>cv2x_subframe_to_symbol_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cv2x_subframe_to_symbol_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>howto_ofdm_cyclic_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>lte_extract_subcarriers_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>howto_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>lte_rough_symbol_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>howto_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_extract_subcarriers_vcvc_0</source_block_id><sink_block_id>lte_pss_calculator_vcm_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_pss_calculator_vcm_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>N_id_2</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>lte_pss_calculator_vcm_0</source_block_id><sink_block_id>lte_pss_symbol_selector_cvc_0</sink_block_id><source_key>half_frame</source_key><sink_key>half_frame</sink_key></connection>
<connection><source_block_id>lte_pss_calculator_vcm_0</source_block_id><sink_block_id>lte_pss_symbol_selector_cvc_0</sink_block_id><source_key>lock</source_key><sink_key>lock</sink_key></connection>
<connection><source_block_id>lte_pss_symbol_selector_cvc_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_rough_symbol_sync_cc_0</source_block_id><sink_block_id>lte_pss_symbol_selector_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
