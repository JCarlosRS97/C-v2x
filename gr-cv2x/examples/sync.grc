<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>comment</key><value>N_RB_sc*N_UL_RB</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32e3</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/jcrs/Escritorio/Bloques/gr-cv2x/build/out.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_len</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/jcrs/Escritorio/Bloques/gr-cv2x/python/tx.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>10000000</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>cv2x_extract_subcarriers_vcvc</key>
<param><key>id</key><value>cv2x_extract_subcarriers_vcvc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
<param><key>N_rb</key><value>6</value></param>
</block>
<block>
<key>cv2x_pss_calculator_vcm</key>
<param><key>id</key><value>cv2x_pss_calculator_vcm_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
</block>
<block>
<key>cv2x_pss_symbol_selector_cvc</key>
<param><key>id</key><value>cv2x_pss_symbol_selector_cvc_0</value></param>
<param><key>fft</key><value>fft_len</value></param>
<param><key>syncPeriod</key><value>10</value></param>
</block>
<block>
<key>cv2x_rough_symbol_sync_cc</key>
<param><key>id</key><value>cv2x_rough_symbol_sync_cc_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>fft_len</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>cv2x_pss_symbol_selector_cvc_0</sink_block_id><source_key>strobe</source_key><sink_key>half_frame</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>cv2x_pss_symbol_selector_cvc_0</sink_block_id><source_key>strobe</source_key><sink_key>lock</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>cv2x_rough_symbol_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cv2x_extract_subcarriers_vcvc_0</source_block_id><sink_block_id>cv2x_pss_calculator_vcm_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cv2x_pss_calculator_vcm_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>N_id_2</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>cv2x_pss_calculator_vcm_0</source_block_id><sink_block_id>cv2x_pss_symbol_selector_cvc_0</sink_block_id><source_key>half_frame</source_key><sink_key>half_frame</sink_key></connection>
<connection><source_block_id>cv2x_pss_calculator_vcm_0</source_block_id><sink_block_id>cv2x_pss_symbol_selector_cvc_0</sink_block_id><source_key>lock</source_key><sink_key>lock</sink_key></connection>
<connection><source_block_id>cv2x_pss_symbol_selector_cvc_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cv2x_pss_symbol_selector_cvc_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cv2x_rough_symbol_sync_cc_0</source_block_id><sink_block_id>cv2x_pss_symbol_selector_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>cv2x_extract_subcarriers_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
