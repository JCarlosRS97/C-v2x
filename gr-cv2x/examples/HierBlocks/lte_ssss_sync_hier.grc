<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lte_ssss_sync</value></param>
<param><key>author</key><value>Juan Carlos Ruiz Sicilia</value></param>
<param><key>category</key><value>[cv2x]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>LTE SSSS Sync</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/carlos/Escritorio/matlab/data/ssss.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>64</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>10</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>64</value></param>
</block>
<block>
<key>cv2x_ssss_calculator_vcm</key>
<param><key>id</key><value>cv2x_ssss_calculator_vcm_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
<param><key>syncPeriod</key><value>syncPeriod</value></param>
<param><key>key_id</key><value>"N_id_2"</value></param>
<param><key>key_offset</key><value>"offset_marker"</value></param>
</block>
<block>
<key>cv2x_ssss_symbol_selector_cvc</key>
<param><key>id</key><value>cv2x_ssss_symbol_selector_cvc_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
<param><key>syncPeriod</key><value>syncPeriod</value></param>
</block>
<block>
<key>cv2x_ssss_tagger_cc</key>
<param><key>id</key><value>cv2x_ssss_tagger_cc_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
<param><key>syncPeriod</key><value>syncPeriod</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>label</key><value>FFT length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>64</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>SLSSID</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>Sync_end</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>syncPeriod</value></param>
<param><key>label</key><value>Sync Period</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>160</value></param>
</block>
<connection><source_block_id>blocks_head_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cv2x_ssss_calculator_vcm_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>cell_id</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>cv2x_ssss_calculator_vcm_0</source_block_id><sink_block_id>cv2x_ssss_tagger_cc_0</sink_block_id><source_key>frame_start</source_key><sink_key>frame_start</sink_key></connection>
<connection><source_block_id>cv2x_ssss_symbol_selector_cvc_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cv2x_ssss_symbol_selector_cvc_0</source_block_id><sink_block_id>pad_sink_1_0</sink_block_id><source_key>sync_end</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>cv2x_ssss_tagger_cc_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_head_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>cv2x_ssss_calculator_vcm_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>cv2x_ssss_symbol_selector_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>cv2x_ssss_tagger_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
