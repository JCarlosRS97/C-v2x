<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tx_v2x</value></param>
<param><key>author</key><value>Juan Carlos Ruiz Sicilia</value></param>
<param><key>category</key><value>[cv2x]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Transmisor V2X</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>SubcarrierBW*fft_len</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>SubcarrierBW</value></param>
<param><key>label</key><value>SubcarrierBW</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>15000</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>7500</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_len</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/carlos/Escritorio/bloques/C-v2x/gr-cv2x/examples/random.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>256</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>cv2x_lte_cyclic_prefixer_vcc</key>
<param><key>id</key><value>cv2x_lte_cyclic_prefixer_vcc_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
</block>
<block>
<key>cv2x_slss_generator</key>
<param><key>id</key><value>cv2x_slss_generator_0</value></param>
<param><key>NFFT</key><value>fft_len</value></param>
<param><key>slssId</key><value>slss_id</value></param>
<param><key>syncPeriod</key><value>syncPeriod</value></param>
<param><key>syncOffsetIndicator1</key><value>0</value></param>
<param><key>syncOffsetIndicator2</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>label</key><value>fft_len</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fft_len</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>slss_id</value></param>
<param><key>label</key><value>SLSS ID</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>120</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>syncPeriod</value></param>
<param><key>label</key><value>syncPeriod</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>160</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cv2x_lte_cyclic_prefixer_vcc_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>cv2x_slss_generator_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>cv2x_lte_cyclic_prefixer_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
