<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ltev_psss_sync</value></param>
<param><key>author</key><value>Juan Carlos Ruiz Sicilia</value></param>
<param><key>category</key><value>[cv2x]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>LTE-V PSSS Sync</value></param>
</block>
<block>
<key>cv2x_extract_subcarriers_vcvc</key>
<param><key>id</key><value>cv2x_extract_subcarriers_vcvc_0</value></param>
<param><key>fftl</key><value>fft_len/8</value></param>
<param><key>N_rb</key><value>6</value></param>
</block>
<block>
<key>cv2x_pss_calculator_vcm</key>
<param><key>id</key><value>cv2x_pss_calculator_vcm_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
<param><key>syncPeriod</key><value>syncPeriod</value></param>
</block>
<block>
<key>cv2x_pss_symbol_selector_cvc</key>
<param><key>id</key><value>cv2x_pss_symbol_selector_cvc_0</value></param>
<param><key>fft</key><value>fft_len/8</value></param>
<param><key>syncPeriod</key><value>syncPeriod</value></param>
</block>
<block>
<key>cv2x_pss_tagger_cc</key>
<param><key>id</key><value>cv2x_pss_tagger_cc_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
<param><key>syncPeriod</key><value>syncPeriod</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>label</key><value>FFT length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_1</value></param>
<param><key>fft_size</key><value>fft_len/8</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>8</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>syncPeriod</value></param>
<param><key>label</key><value>Sync Period</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>160</value></param>
</block>
<connection><source_block_id>cv2x_extract_subcarriers_vcvc_0</source_block_id><sink_block_id>cv2x_pss_calculator_vcm_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cv2x_pss_calculator_vcm_0</source_block_id><sink_block_id>cv2x_pss_tagger_cc_0</sink_block_id><source_key>N_id_2</source_key><sink_key>N_id_2</sink_key></connection>
<connection><source_block_id>cv2x_pss_calculator_vcm_0</source_block_id><sink_block_id>cv2x_pss_symbol_selector_cvc_0</sink_block_id><source_key>lock</source_key><sink_key>lock</sink_key></connection>
<connection><source_block_id>cv2x_pss_calculator_vcm_0</source_block_id><sink_block_id>cv2x_pss_tagger_cc_0</sink_block_id><source_key>lock</source_key><sink_key>lock</sink_key></connection>
<connection><source_block_id>cv2x_pss_calculator_vcm_0</source_block_id><sink_block_id>cv2x_pss_symbol_selector_cvc_0</sink_block_id><source_key>sync_frame</source_key><sink_key>sync_frame</sink_key></connection>
<connection><source_block_id>cv2x_pss_calculator_vcm_0</source_block_id><sink_block_id>cv2x_pss_tagger_cc_0</sink_block_id><source_key>sync_frame</source_key><sink_key>sync_frame</sink_key></connection>
<connection><source_block_id>cv2x_pss_symbol_selector_cvc_0</source_block_id><sink_block_id>fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cv2x_pss_tagger_cc_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_1</source_block_id><sink_block_id>cv2x_extract_subcarriers_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>cv2x_pss_tagger_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>cv2x_pss_symbol_selector_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
