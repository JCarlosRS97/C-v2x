<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>comment</key><value>N_RB_sc*N_UL_RB</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>30720000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>syncPeriod</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>-7500</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/jcrs/Escritorio/Bloques/gr-cv2x/build/python/trasselector.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_len</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/jcrs/Escritorio/Bloques/gr-cv2x/build/python/trasfft.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>512</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>num_items</key><value>45</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_len</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>512*50</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>512</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate/fft_len</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_len</value></param>
</block>
<block>
<key>cv2x_extract_subcarriers_vcvc</key>
<param><key>id</key><value>cv2x_extract_subcarriers_vcvc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
<param><key>N_rb</key><value>6</value></param>
</block>
<block>
<key>cv2x_pss_calculator_vcm</key>
<param><key>id</key><value>cv2x_pss_calculator_vcm_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
</block>
<block>
<key>cv2x_pss_symbol_selector_cvc</key>
<param><key>id</key><value>cv2x_pss_symbol_selector_cvc_0</value></param>
<param><key>fft</key><value>fft_len</value></param>
<param><key>syncPeriod</key><value>syncPeriod</value></param>
</block>
<block>
<key>cv2x_rough_symbol_sync_cc</key>
<param><key>id</key><value>cv2x_rough_symbol_sync_cc_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>cv2x_slss_generator</key>
<param><key>id</key><value>cv2x_slss_generator_0</value></param>
<param><key>NFFT</key><value>fft_len</value></param>
<param><key>slssId</key><value>101</value></param>
<param><key>syncPeriod</key><value>syncPeriod</value></param>
<param><key>syncOffsetIndicator1</key><value>0</value></param>
<param><key>syncOffsetIndicator2</key><value>0</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fft_len</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_1</value></param>
<param><key>fft_size</key><value>fft_len</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>foo_random_periodic_msg_source</key>
<param><key>id</key><value>foo_random_periodic_msg_source_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>msg_len</key><value>64</value></param>
<param><key>num</key><value>1</value></param>
<param><key>interval</key><value>100000000</value></param>
<param><key>quit</key><value>True</value></param>
<param><key>seed</key><value>1</value></param>
</block>
<block>
<key>howto_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>howto_ofdm_cyclic_prefixer_0</value></param>
<param><key>cp_lengths</key><value>(int(160.0/2048*fft_len), int(144.0/2048*fft_len), int(144.0/2048*fft_len), int(144.0/2048*fft_len), int(144.0/2048*fft_len), int(144.0/2048*fft_len),int(144.0/2048*fft_len))</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>len_tag_key</key><value></value></param>
<param><key>rolloff</key><value>0</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cv2x_extract_subcarriers_vcvc_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cv2x_extract_subcarriers_vcvc_0</source_block_id><sink_block_id>cv2x_pss_calculator_vcm_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cv2x_pss_calculator_vcm_0</source_block_id><sink_block_id>blocks_message_debug_1</sink_block_id><source_key>N_id_2</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>cv2x_pss_calculator_vcm_0</source_block_id><sink_block_id>cv2x_pss_symbol_selector_cvc_0</sink_block_id><source_key>half_frame</source_key><sink_key>half_frame</sink_key></connection>
<connection><source_block_id>cv2x_pss_calculator_vcm_0</source_block_id><sink_block_id>cv2x_pss_symbol_selector_cvc_0</sink_block_id><source_key>lock</source_key><sink_key>lock</sink_key></connection>
<connection><source_block_id>cv2x_pss_symbol_selector_cvc_0</source_block_id><sink_block_id>fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cv2x_rough_symbol_sync_cc_0</source_block_id><sink_block_id>cv2x_pss_symbol_selector_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cv2x_slss_generator_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>howto_ofdm_cyclic_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_1</source_block_id><sink_block_id>blocks_head_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_1</source_block_id><sink_block_id>cv2x_extract_subcarriers_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_random_periodic_msg_source_0</source_block_id><sink_block_id>cv2x_pss_symbol_selector_cvc_0</sink_block_id><source_key>out</source_key><sink_key>half_frame</sink_key></connection>
<connection><source_block_id>foo_random_periodic_msg_source_0</source_block_id><sink_block_id>cv2x_pss_symbol_selector_cvc_0</sink_block_id><source_key>out</source_key><sink_key>lock</sink_key></connection>
<connection><source_block_id>howto_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>howto_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>cv2x_rough_symbol_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
